<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\TIM4_delay\TIM4_delay.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
