<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\uart\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
